# Keil uVision project walkingpad.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89S105K8 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xFFFF) CLOCK(32000000)
  output: walkingpad +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  group Source Group 1
    ./: STARTUP.A51 commu.c displaydriver.c ini.c main.c
    ./src/: beep.c control.c eeprom.c error.c factory.c fan.c image.c key.c miwifi.c motion.c program.c rc.c run_mode.c sensor.c time.c
