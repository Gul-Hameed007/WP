# Keil uVision project BootLoader.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89S105K8 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xFFFF) CLOCK(32000000)
  output: BootLoader +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c xmodem.c
